options:
  parameters:
    author: aminmahjoub
    generate_options: qt_gui
    id: ssb_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rfGain
  id: variable_qtgui_range
  parameters:
    label: RF Gain DB
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/aminmahjoub/Documents/pcb/radio/code/gnu-radio/audio/tidal_48k.wav
    repeat: 'True'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1, 48000, 3000, 500)
    type: fff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '241'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: BASEBAND SPECTURM
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2e6
    fc: 10e6
    fftsize: '8192'
    grid: 'True'
    name: LSB RF SPECTURM
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '125'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: 10e6
    samp_rate: 2e6
    type: fc32
    vga: rfGain
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', hilbert_fc_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [hilbert_fc_0, '0', blocks_conjugate_cc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
