options:
  parameters:
    author: aminmahjoub
    generate_options: qt_gui
    id: ft8_receiver
    output_language: python
    title: FT8 Receiver
  states: {}

blocks:
- name: audio_sample
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Dial frequency (Hz)
    start: 1e6
    step: 1e3
    stop: 30e6
    value: 10e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: Volume (dB)
    start: '-100'
    step: '0.1'
    stop: '10'
    value: '-6'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '7e-2'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: 1e6
    reference: '0.3'
    type: complex
  states: {}
- name: audio_level
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'views@0: 2,1,1,1'
    label1: audio
    legend: 'False'
    name: Audio level
    size: '4096'
    srate: samp_rate
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_sample
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '127'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(volume/20)
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '128'
    long_form: 'True'
    type: ff
  states: {}
- name: display_decim
  id: rational_resampler_xxx
  parameters:
    comment: 6 kHz for the FT8 plots
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import time

      import numpy as np
      import zmq
      from gnuradio import gr

      # Must match CONTROL in iq_bridge.py. Kept as a constant rather than a GRC
      # parameter: an empty field there generates `endpoint=` and fails to compile,
      # and a wrong one fails silently, since ZMQ PUB discards messages nobody is
      # subscribed to.
      CONTROL = 'tcp://127.0.0.1:5556'


      class blk(gr.sync_block):
          """Tune the radio board from GRC.

          Samples pass through untouched; the block exists for its `freq` parameter,
          which is forwarded to iq_bridge.py over ZMQ. Wire a QT GUI Range widget to
          a variable and set freq to that variable -- GRC calls the setter whenever
          the slider moves.

          Frequencies are the station, not the LO: the bridge applies the Tayloe
          divide-by-four and the tuning offset itself, so 1170e3 means 1170 kHz.
          """

          def __init__(self, freq=1.17e6):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Board Tuner',             # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self._ctx = zmq.Context()
              self._sock = self._ctx.socket(zmq.PUB)
              self._sock.connect(CONTROL)

              # PUB silently discards anything sent before the subscriber has
              # connected, so a request sent immediately would vanish anyway.
              time.sleep(0.3)

              # Adopt the starting frequency WITHOUT transmitting it. The flowgraph
              # is constructed on every run, and sending here would abort the
              # bridge's stream and cost a second of audio at each start -- right
              # when you are listening for it to begin. The bridge already has a
              # frequency; nudge the slider if the two disagree.
              self._freq = float(freq)

          # A property, so GRC registers a callback on the matching parameter name.
          @property
          def freq(self):
              return self._freq

          @freq.setter
          def freq(self, value):
              value = float(value)
              # Retuning costs a second of audio -- the bridge has to abort the
              # stream, send the command and restart -- so ignore no-op updates.
              if value != self._freq:
                  self._freq = value
                  self._sock.send(str(value).encode())

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    freq: frequency
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '5000'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 3000, 500)
    type: ccf
  states: {}
- name: ft8_decoder
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: FT8 decoder.

      Paste into an Embedded Python Block in board/ft8_receiver.grc, inline on the
      real SSB audio (DC Blocker -> this -> resampler); audio passes through. At every
      UTC 15 s boundary it decodes the last 30 s in a background thread, so the
      flowgraph never stalls, and prints each new message to the console.

      Decoding lives in radiolib; this file is buffering and output only.
      """

      import threading
      import time
      from math import gcd

      import numpy as np
      from gnuradio import gr
      from radiolib.ft8 import FS, FT8, stft
      from scipy.signal import resample_poly

      SLOT_S = 15
      WINDOW_S = 30   # two slots, so a transmission off the slot boundaries still fits whole


      class blk(gr.sync_block):
          """Decode FT8 from real SSB audio, passing the audio through."""

          def __init__(self, samp_rate=24000, dial_hz=7.074e6):
              """
              Set up the audio buffer.

              Args:
                  samp_rate (int): input sample rate, Hz
                  dial_hz (float): receiver dial frequency, Hz, added to audio frequency for RF
              """
              gr.sync_block.__init__(self, name="FT8 Decoder", in_sig=[np.float32],
                                     out_sig=[np.float32])
              self.samp_rate = int(samp_rate)
              # same name as the parameter, so GRC updates it when the dial moves
              self.dial_hz = dial_hz
              self._ft8 = FT8()
              self._chunks, self._n = [], 0
              self._slot = None
              self._busy = threading.Lock()
              self._seen = []

          def work(self, input_items, output_items):
              """
              Pass the audio through, keeping the last 30 s and starting a decode at each UTC slot boundary.

              Args:
                  input_items (list of np.ndarray): one float32 audio stream
                  output_items (list of np.ndarray): the same audio, unchanged

              Returns:
                  int: number of samples produced
              """
              x = input_items[0]
              output_items[0][:] = x
              now = time.time()
              self._chunks.append(x.copy())
              self._n += len(x)
              while self._n - len(self._chunks[0]) >= WINDOW_S * self.samp_rate:
                  self._n -= len(self._chunks.pop(0))

              slot = int(now // SLOT_S)
              if slot != self._slot:
                  first = self._slot is None
                  self._slot = slot
                  enough = self._n >= 13 * self.samp_rate
                  # skip this boundary if the previous decode is still running
                  if not first and enough and self._busy.acquire(blocking=False):
                      audio = np.concatenate(self._chunks)
                      threading.Thread(target=self._decode, args=(audio, now), daemon=True).start()
              return len(output_items[0])

          def _decode(self, audio, t_end):
              """
              Decode one window and print each message not already reported.

              Args:
                  audio (np.ndarray): up to 30 s of audio at samp_rate
                  t_end (float): UNIX time of the last sample, s
              """
              try:
                  g = gcd(FS, self.samp_rate)
                  y = resample_poly(audio - audio.mean(), FS // g, self.samp_rate // g)
                  wf = stft(y, fs=FS)
                  t_start = t_end - len(audio) / self.samp_rate
                  for t0, f0, score, payload in self._ft8.decode(wf):
                      t = t_start + float(wf.t[t0])
                      hexp = f"{int(''.join(map(str, payload)), 2):020x}"
                      # consecutive windows overlap by 15 s, so most messages turn up twice
                      if any(abs(t - ts) < 1.0 and hexp == p for ts, p in self._seen):
                          continue
                      self._seen.append((t, hexp))
                      f = float(wf.f[f0])
                      stamp = time.strftime("%H:%M:%S", time.gmtime(t)) + f"{t % 1:.1f}"[1:]
                      print(f"FT8 {stamp} UTC  {f:7.1f} Hz  {self.dial_hz + f:10.0f} Hz  "
                            f"sync {score:5.1f}  {hexp}", flush=True)
                  self._seen = [(ts, p) for ts, p in self._seen if ts > t_end - 2 * WINDOW_S]
              finally:
                  self._busy.release()
    samp_rate: samp_rate
    dial_hz: frequency
  states: {}
- name: ft8_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/4
    color1: '3'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 'views@0: 0,0,2,2'
    int_max: '-30'
    int_min: '-110'
    name: FT8 band (audio Hz)
    type: float
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '255'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'views@1: 2,0,1,1'
    name: Board I/Q spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/4
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 'views@0: 2,0,1,1'
    label: Relative gain
    label1: audio
    legend: 'False'
    name: FT8 band spectrum
    type: float
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'views@1: 2,1,1,1'
    label1: I/Q
    name: Board I/Q samples
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 24e3
    fc: frequency-5e3
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'views@1: 0,0,2,2'
    name: Board I/Q (RF Hz)
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: fff
  states: {}
- name: views
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,10,4
    num_tabs: '2'
    label0: FT8 audio
    label1: Board I/Q
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_imag_0, '0']
- [analog_agc2_xx_0, '0', blocks_complex_to_real_2, '0']
- [blocks_add_xx_1, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_imag_0, '0', hilbert_fc_1, '0']
- [blocks_complex_to_imag_0_0, '0', blocks_add_xx_1, '1']
- [blocks_complex_to_real_2, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', ft8_decoder, '0']
- [display_decim, '0', ft8_waterfall, '0']
- [display_decim, '0', qtgui_freq_sink_x_0_0, '0']
- [epy_block_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [ft8_decoder, '0', audio_level, '0']
- [ft8_decoder, '0', blocks_multiply_const_vxx_0, '0']
- [ft8_decoder, '0', display_decim, '0']
- [hilbert_fc_1, '0', blocks_complex_to_imag_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [zeromq_sub_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
