options:
  parameters:
    author: aminmahjoub
    generate_options: qt_gui
    id: ft8_wsjtx
    output_language: python
    title: FT8 Receiver -> WSJT-X
  states: {}

blocks:
- name: audio_sample
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Dial frequency (Hz)
    start: 1e6
    step: 1e3
    stop: 30e6
    value: 10e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Level to WSJT-X (dB)
    start: '-100'
    step: '0.1'
    stop: '10'
    value: '-6'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '7e-2'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: 1e6
    reference: '0.3'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: 'WSJT-X: Settings > Audio > Input = BlackHole 2ch, Mono'
    device_name: BlackHole 2ch
    samp_rate: audio_sample
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '127'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(volume/20)
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '128'
    long_form: 'True'
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import time

      import numpy as np
      import zmq
      from gnuradio import gr

      # Must match CONTROL in iq_bridge.py. Kept as a constant rather than a GRC
      # parameter: an empty field there generates `endpoint=` and fails to compile,
      # and a wrong one fails silently, since ZMQ PUB discards messages nobody is
      # subscribed to.
      CONTROL = 'tcp://127.0.0.1:5556'


      class blk(gr.sync_block):
          """Tune the radio board from GRC.

          Samples pass through untouched; the block exists for its `freq` parameter,
          which is forwarded to iq_bridge.py over ZMQ. Wire a QT GUI Range widget to
          a variable and set freq to that variable -- GRC calls the setter whenever
          the slider moves.

          Frequencies are the station, not the LO: the bridge applies the Tayloe
          divide-by-four and the tuning offset itself, so 1170e3 means 1170 kHz.
          """

          def __init__(self, freq=1.17e6):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Board Tuner',             # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self._ctx = zmq.Context()
              self._sock = self._ctx.socket(zmq.PUB)
              self._sock.connect(CONTROL)

              # PUB silently discards anything sent before the subscriber has
              # connected, so a request sent immediately would vanish anyway.
              time.sleep(0.3)

              # Adopt the starting frequency WITHOUT transmitting it. The flowgraph
              # is constructed on every run, and sending here would abort the
              # bridge's stream and cost a second of audio at each start -- right
              # when you are listening for it to begin. The bridge already has a
              # frequency; nudge the slider if the two disagree.
              self._freq = float(freq)

          # A property, so GRC registers a callback on the matching parameter name.
          @property
          def freq(self):
              return self._freq

          @freq.setter
          def freq(self, value):
              value = float(value)
              # Retuning costs a second of audio -- the bridge has to abort the
              # stream, send the command and restart -- so ignore no-op updates.
              if value != self._freq:
                  self._freq = value
                  self._sock.send(str(value).encode())

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    freq: frequency
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '5000'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 3000, 500)
    type: ccf
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '255'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RAW IQ Specturm
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: REAL Signal Specturm
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 24e3
    fc: frequency-5e3
    fftsize: '4096'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: fff
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_imag_0, '0']
- [analog_agc2_xx_0, '0', blocks_complex_to_real_2, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_imag_0, '0', hilbert_fc_1, '0']
- [blocks_complex_to_imag_0_0, '0', blocks_add_xx_1, '1']
- [blocks_complex_to_real_2, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [hilbert_fc_1, '0', blocks_complex_to_imag_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [zeromq_sub_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
