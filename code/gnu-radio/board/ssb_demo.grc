options:
  parameters:
    author: Barry Duggan
    description: SSB_demo
    generate_options: qt_gui
    id: ssb_demo
    output_language: python
    title: SSB_demo_2
  states: {}

blocks:
- name: audio_sample
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: bfo
  id: variable_qtgui_range
  parameters:
    comment: 2,0,1,4
    gui_hint: 2,0,1,4
    label: Fine tuning
    start: '0'
    step: '10'
    stop: '3000'
    value: '1500'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1e6
    step: 10e3
    stop: 11e6
    value: 1.7e6
  states: {}
- name: input_gain
  id: variable_qtgui_range
  parameters:
    label: Input Gain
    start: '-300'
    step: '0.1'
    stop: '10'
    value: '-300'
  states: {}
- name: rcv_select
  id: variable_qtgui_chooser
  parameters:
    comment: 3,1,1,1
    gui_hint: 3,1,1,1
    label: Receive method
    label0: Filter
    label1: Weaver
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: sb_sel
  id: variable_qtgui_chooser
  parameters:
    comment: 3,3,1,1
    gui_hint: 3,3,1,1
    label: Weaver rcv SB
    label0: Upper
    label1: Lower
    num_opts: '2'
    option0: '-1'
    option1: '1'
    type: int
    value: '-1'
    widget: radio_buttons
  states: {}
- name: sb_sel_r
  id: variable_qtgui_chooser
  parameters:
    comment: 3,2,1,1
    gui_hint: 3,2,1,1
    label: Filter rcv SB
    label0: Upper
    label1: Lower
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: sb_sel_t
  id: variable_qtgui_chooser
  parameters:
    comment: 3,0,1,1
    gui_hint: 3,0,1,1
    label: Transmit Sideband
    label0: Upper
    label1: Lower
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: raw
    value: '0'
    widget: radio_buttons
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label: Volume (dB)
    start: '-60'
    step: '1'
    stop: '30'
    value: '-60'
  states: {}
- name: volume_0
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '-100'
    step: '0.1'
    stop: '10'
    value: '-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: bfo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: bfo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Weaver rcv SB select
    const: sb_sel
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    comment: Filter rcv SB
    enabled: 'True'
    input_index: sb_sel_r
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    comment: Receive method
    enabled: 'True'
    input_index: rcv_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_swapiq_0_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import time

      import numpy as np
      import zmq
      from gnuradio import gr

      # Must match CONTROL in iq_bridge.py. Kept as a constant rather than a GRC
      # parameter: an empty field there generates `endpoint=` and fails to compile,
      # and a wrong one fails silently, since ZMQ PUB discards messages nobody is
      # subscribed to.
      CONTROL = 'tcp://127.0.0.1:5556'


      class blk(gr.sync_block):
          """Tune the radio board from GRC.

          Samples pass through untouched; the block exists for its `freq` parameter,
          which is forwarded to iq_bridge.py over ZMQ. Wire a QT GUI Range widget to
          a variable and set freq to that variable -- GRC calls the setter whenever
          the slider moves.

          Frequencies are the station, not the LO: the bridge applies the Tayloe
          divide-by-four and the tuning offset itself, so 1170e3 means 1170 kHz.
          """

          def __init__(self, freq=1.17e6):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Board Tuner',             # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self._ctx = zmq.Context()
              self._sock = self._ctx.socket(zmq.PUB)
              self._sock.connect(CONTROL)

              # PUB silently discards anything sent before the subscriber has
              # connected, so a request sent immediately would vanish anyway.
              time.sleep(0.3)

              # Adopt the starting frequency WITHOUT transmitting it. The flowgraph
              # is constructed on every run, and sending here would abort the
              # bridge's stream and cost a second of audio at each start -- right
              # when you are listening for it to begin. The bridge already has a
              # frequency; nudge the slider if the two disagree.
              self._freq = float(freq)

          # A property, so GRC registers a callback on the matching parameter name.
          @property
          def freq(self):
              return self._freq

          @freq.setter
          def freq(self, value):
              value = float(value)
              # Retuning costs a second of audio -- the bridge has to abort the
              # stream, send the command and restart -- so ignore no-op updates.
              if value != self._freq:
                  self._freq = value
                  self._sock.send(str(value).encode())

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    freq: frequency
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ' 3000 + sb_sel*(-1500)'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate/2, 1500)
    type: ccf
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Numbers under GUI blocks are GUI hints
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: fff
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_selector_2, '1']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_selector_2, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_selector_0_0, '0', fft_filter_xxx_0, '0']
- [blocks_selector_2, '0', rational_resampler_xxx_0, '0']
- [blocks_swapiq_0_0, '0', blocks_selector_0_0, '1']
- [epy_block_0, '0', blocks_selector_0_0, '0']
- [epy_block_0, '0', blocks_swapiq_0_0, '0']
- [epy_block_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_real_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_sub_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
