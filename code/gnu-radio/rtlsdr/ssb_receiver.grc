options:
  parameters:
    author: aminmahjoub
    generate_options: qt_gui
    id: ssb_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_sample
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 7.125e6
    step: '100'
    stop: 7.3e6
    value: 7.2e6
  states: {}
- name: input_gain
  id: variable_qtgui_range
  parameters:
    label: Input Gain
    start: '-300'
    step: '0.1'
    stop: '10'
    value: '-300'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '-100'
    step: '0.1'
    stop: '10'
    value: '-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_sample
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '32'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '3000'
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 5000, 3000)
    type: ccc
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: Zero-IF puts the board's DC offset and 1/f noise at 0 Hz audio.
    cutoff_freq: '250'
    gain: '1'
    interp: '1'
    samp_rate: '48000'
    type: interp_fir_filter_fff
    width: '150'
    win: window.WIN_HAMMING
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '8192'
    grid: 'True'
    name: Input signal water fall
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 32e3
    fc: frequency
    fftsize: '1024'
    grid: 'True'
    name: LSB Waterfall
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_xx_1, '0', high_pass_filter_0, '0']
- [blocks_complex_to_imag_0, '0', hilbert_fc_1, '0']
- [blocks_complex_to_imag_0_0, '0', blocks_add_xx_1, '1']
- [blocks_complex_to_real_2, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_imag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_real_2, '0']
- [high_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [hilbert_fc_1, '0', blocks_complex_to_imag_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
